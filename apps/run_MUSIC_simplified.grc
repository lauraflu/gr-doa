<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>run_MUSIC_lin_array_simulation</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amv0</value></param>
<param><key>value</key><value>numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta0))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amv1</value></param>
<param><key>value</key><value>numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ant_locs</value></param>
<param><key>value</key><value>numpy.dot(input_variables.NormSpacing, numpy.arange(input_variables.NumArrayElements/2, -input_variables.NumArrayElements/2, -1) if (input_variables.NumArrayElements%2==1) else numpy.arange(input_variables.NumArrayElements/2-0.5, -input_variables.NumArrayElements/2-0.5, -1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>array_manifold_matrix</value></param>
<param><key>value</key><value>numpy.array([amv0, amv1]).transpose()</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>field0</key><value>SampleRate</value></param>
<param><key>field1</key><value>ToneFreq1</value></param>
<param><key>field2</key><value>ToneFreq2</value></param>
<param><key>field3</key><value>NormSpacing</value></param>
<param><key>field4</key><value>NumTargets</value></param>
<param><key>field5</key><value>NumArrayElements</value></param>
<param><key>field6</key><value>PSpectrumLength</value></param>
<param><key>field7</key><value>SnapshotSize</value></param>
<param><key>field8</key><value>OverlapSize</value></param>
<param><key>value3</key><value>0.4</value></param>
<param><key>value5</key><value>4</value></param>
<param><key>value4</key><value>2</value></param>
<param><key>value8</key><value>2**9</value></param>
<param><key>value6</key><value>2**10</value></param>
<param><key>value0</key><value>320000</value></param>
<param><key>value7</key><value>2**11</value></param>
<param><key>value1</key><value>10000</value></param>
<param><key>value2</key><value>20000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>theta0</value></param>
<param><key>value</key><value>numpy.pi*theta0_deg/180</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>theta0_deg</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>theta1</value></param>
<param><key>value</key><value>numpy.pi*theta1_deg/180</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>theta1_deg</value></param>
<param><key>value</key><value>123</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>input_variables.ToneFreq1</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>input_variables.SampleRate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>input_variables.ToneFreq2</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>input_variables.SampleRate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_multiply_matrix_xx</key>
<param><key>id</key><value>blocks_multiply_matrix_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>A</key><value>array_manifold_matrix</value></param>
<param><key>tag_propagation_policy</key><value>gr.TPP_ALL_TO_ALL</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>input_variables.NumTargets</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>input_variables.NumTargets</value></param>
</block>
<block>
<key>doa_MUSIC_lin_array</key>
<param><key>id</key><value>doa_MUSIC_lin_array_0</value></param>
<param><key>norm_spacing</key><value>input_variables.NormSpacing</value></param>
<param><key>inputs</key><value>input_variables.NumArrayElements</value></param>
<param><key>num_targets</key><value>input_variables.NumTargets</value></param>
<param><key>pspectrum_len</key><value>input_variables.PSpectrumLength</value></param>
</block>
<block>
<key>doa_autocorrelate</key>
<param><key>id</key><value>doa_autocorrelate_0</value></param>
<param><key>avg_method</key><value>1</value></param>
<param><key>inputs</key><value>input_variables.NumArrayElements</value></param>
<param><key>overlap_size</key><value>input_variables.OverlapSize</value></param>
<param><key>snapshot_size</key><value>input_variables.SnapshotSize</value></param>
</block>
<block>
<key>doa_find_local_max</key>
<param><key>id</key><value>doa_find_local_max_0</value></param>
<param><key>num_max_vals</key><value>input_variables.NumTargets</value></param>
<param><key>vector_len</key><value>input_variables.PSpectrumLength</value></param>
<param><key>x_max</key><value>180.0</value></param>
<param><key>x_min</key><value>0.0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>doa_MUSIC_lin_array_0</source_block_id><sink_block_id>doa_find_local_max_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_autocorrelate_0</source_block_id><sink_block_id>doa_MUSIC_lin_array_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_find_local_max_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
